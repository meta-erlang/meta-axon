FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://gravitonKernelConfigs.cfg "
