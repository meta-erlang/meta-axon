require recipes-graphics/images/core-image-x11.bb

DESCRIPTION = "A very basic X11 image with a terminal and axon-scenic"

IMAGE_INSTALL += " axon-scenic"
