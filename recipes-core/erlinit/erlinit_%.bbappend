FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://erlinit.config \
    "
